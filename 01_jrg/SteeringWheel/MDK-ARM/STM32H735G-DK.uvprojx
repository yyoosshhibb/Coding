# Keil uVision project STM32H735G-DK.uvprojx, settings and files
target STM32H735G-DK (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H735IGKx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32H735G-DK +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H735xx
  c include: ../Core/Inc;../TouchGFX/App;../TouchGFX/target/generated;../TouchGFX/target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP/Components/Common;../Drivers/BSP/STM32H735G-DK;../middlewares/st/touchgfx/framework/include;../touchgfx/generated/fonts/include;../touchgfx/generated/gui_generated/include;../touchgfx/generated/images/include;../touchgfx/generated/texts/include;../touchgfx/generated/videos/include;../touchgfx/gui/include
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  scatter file: .\STM32H735G-DK.sct
  group Application/MDK-ARM
    ./: startup_stm32h735xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c crc.c dma2d.c eth.c fdcan.c i2c.c ltdc.c octospi.c sai.c sdmmc.c tim.c usb_otg.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: CortexMMCUInstrumentation.cpp TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group Drivers/BSP/STM32H735G-DK
    ../Drivers/BSP/STM32H735G-DK/: stm32h735g_discovery_ospi.c stm32h735g_discovery_ts.c stm32h735g_discovery_bus.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/s70kl1281/: s70kl1281.c
    ../Drivers/BSP/Components/mx25lm51245g/: mx25lm51245g.c
    ../Drivers/BSP/Components/ft5336/: ft5336.c ft5336_reg.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_ospi.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group gui
    ../touchgfx/gui/src/battery_screen/: batterypresenter.cpp batteryview.cpp
    ../touchgfx/gui/src/boot_screen/: bootpresenter.cpp bootview.cpp
    ../touchgfx/gui/src/driver_screen/: driverpresenter.cpp driverview.cpp
    ../touchgfx/gui/src/electrics_screen/: electricspresenter.cpp electricsview.cpp
    ../touchgfx/gui/src/epowertrain_screen/: epowertrainpresenter.cpp epowertrainview.cpp
    ../touchgfx/gui/src/common/: frontendapplication.cpp
    ../touchgfx/gui/src/home_screen/: homepresenter.cpp homeview.cpp
    ../touchgfx/gui/src/inverter_screen/: inverterpresenter.cpp inverterview.cpp
    ../touchgfx/gui/src/model/: model.cpp
    ../touchgfx/gui/src/suspension_screen/: suspensionpresenter.cpp suspensionview.cpp
  group generated
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_gili_____ttf_20_4bpp_0.cpp font_gili_____ttf_50_4bpp_0.cpp font_gili_____ttf_60_4bpp_0.cpp font_verdana_10_4bpp_0.cpp font_verdana_20_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_gili_____ttf_20_4bpp.cpp kerning_gili_____ttf_50_4bpp.cpp kerning_gili_____ttf_60_4bpp.cpp kerning_verdana_10_4bpp.cpp kerning_verdana_20_4bpp.cpp table_gili_____ttf_20_4bpp.cpp table_gili_____ttf_50_4bpp.cpp table_gili_____ttf_60_4bpp.cpp table_verdana_10_4bpp.cpp table_verdana_20_4bpp.cpp unmappeddatafont.cpp
    ../touchgfx/generated/gui_generated/src/battery_screen/: batteryviewbase.cpp
    ../touchgfx/generated/images/src/: bitmapdatabase.cpp image_new_logos_jr22.cpp image_path3439-5-9-0-8-3-3-3-3-34-2-5.cpp
    ../touchgfx/generated/gui_generated/src/boot_screen/: bootviewbase.cpp
    ../touchgfx/generated/gui_generated/src/driver_screen/: driverviewbase.cpp
    ../touchgfx/generated/gui_generated/src/electrics_screen/: electricsviewbase.cpp
    ../touchgfx/generated/gui_generated/src/epowertrain_screen/: epowertrainviewbase.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/gui_generated/src/home_screen/: homeviewbase.cpp
    ../touchgfx/generated/images/src/__designer/: image_dark_progressindicators_bg_medium_progress_indicator_bg_square_0_degrees.cpp
    ../touchgfx/generated/gui_generated/src/inverter_screen/: inverterviewbase.cpp
    ../touchgfx/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../touchgfx/generated/gui_generated/src/suspension_screen/: suspensionviewbase.cpp
  group Lib
    ../middlewares/st/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
software components: CMSIS:CORE 4.3.0
