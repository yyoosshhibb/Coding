# Keil uVision project stm32h745i_disco.uvprojx, settings and files
target STM32H745I_DISCO_CM4 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H745XIHx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x10000000-0x10047FFF) IRAM2(0x18000000-0x1800FFFF) IROM(0x8100000-0x81FFFFF) CLOCK(12000000) FPU2 CPUTYPE("Cortex-M4")
  output: stm32h745i_disco_CM4 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_CM4,USE_HAL_DRIVER,STM32H745xx
  c include: ../CM4/Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include
  asm include: ..\CM4\Core\Inc
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  memory RVCT10: RAM 0x18000000 size 0x10000
  scatter file: stm32h745xx_flash_CM4.sct
  group Application/MDK-ARM
    ./: startup_stm32h745xx_CM4.s startup_stm32h745xx_CM7.s
  group Application/User/CM7/TouchGFX/App
    ../CM7/TouchGFX/App/: app_touchgfx.c
  group Application/User/CM7/TouchGFX/target
    ../CM7/TouchGFX/target/: stm32h745i_touchcontroller.cpp STM32H7Instrumentation.cpp TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/CM7/TouchGFX/target/generated
    ../CM7/TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp
  group Application/User/CM7/Core
    ../CM7/Core/Src/: main_user.c main.c freertos.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c FDCAN_RX.c GUI_Communication.c
    ./: FDCAN_Management.c FDCAN_TX.c Timer_Management.c
  group Application/User/CM4/Core
    ../CM4/Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_fdcan.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx_dualcore_boot_cm4_cm7.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Lib
    ../cm7/middlewares/st/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/ft5336/: ft5336.c ft5336_reg.c
    ../Drivers/BSP/Components/mt25tl01g/: mt25tl01g.c
    ../Drivers/BSP/Components/mt48lc4m32b2/: mt48lc4m32b2.c
  group Drivers/BSP/STM32H745I-DISCO
    ../Drivers/BSP/STM32H745I-DISCO/: stm32h745i_discovery.c stm32h745i_discovery_bus.c stm32h745i_discovery_lcd.c stm32h745i_discovery_qspi.c stm32h745i_discovery_sdram.c stm32h745i_discovery_ts.c
  group Application/User/CM7/Core/Inc
    ../CM7/Core/Inc/: nema_hal_threadx.c
  group gui
    ../cm7/touchgfx/gui/src/common/: frontendapplication.cpp
    ../cm7/touchgfx/gui/src/home_screen/: homepresenter.cpp homeview.cpp
    ../cm7/touchgfx/gui/src/model/: model.cpp
    ../cm7/touchgfx/gui/src/screen2_screen/: screen2presenter.cpp screen2view.cpp
    ../cm7/touchgfx/gui/src/screen3_screen/: screen3presenter.cpp screen3view.cpp
    ../cm7/touchgfx/gui/src/screen4_screen/: screen4presenter.cpp screen4view.cpp
    ../cm7/touchgfx/gui/src/screen5_screen/: screen5presenter.cpp screen5view.cpp
    ../cm7/touchgfx/gui/src/screen6_screen/: screen6presenter.cpp screen6view.cpp
    ../cm7/touchgfx/gui/src/screen7_screen/: screen7presenter.cpp screen7view.cpp
  group generated
    ../cm7/touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_dmsans_bold_20_4bpp_0.cpp font_dmsans_bold_60_4bpp_0.cpp font_dmsans_italic_80_4bpp_0.cpp font_dmsans_regular_40_4bpp_0.cpp font_verdana_10_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_dmsans_bold_20_4bpp.cpp kerning_dmsans_bold_60_4bpp.cpp kerning_dmsans_italic_80_4bpp.cpp kerning_dmsans_regular_40_4bpp.cpp kerning_verdana_10_4bpp.cpp table_dmsans_bold_20_4bpp.cpp table_dmsans_bold_60_4bpp.cpp table_dmsans_italic_80_4bpp.cpp table_dmsans_regular_40_4bpp.cpp table_verdana_10_4bpp.cpp unmappeddatafont.cpp
    ../cm7/touchgfx/generated/images/src/: bitmapdatabase.cpp image_joanneum_racing_battery.cpp image_joanneum_racing_electrics.cpp image_joanneum_racing_graz.cpp image_joanneum_racing_inverter.cpp image_joanneum_racing_powertrain.cpp image_joanneum_racing_suspension.cpp image_joanneum_racing_testing.cpp svgdatabase.cpp
    ../cm7/touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../cm7/touchgfx/generated/gui_generated/src/home_screen/: homeviewbase.cpp
    ../cm7/touchgfx/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../cm7/touchgfx/generated/gui_generated/src/screen2_screen/: screen2viewbase.cpp
    ../cm7/touchgfx/generated/gui_generated/src/screen3_screen/: screen3viewbase.cpp
    ../cm7/touchgfx/generated/gui_generated/src/screen4_screen/: screen4viewbase.cpp
    ../cm7/touchgfx/generated/gui_generated/src/screen5_screen/: screen5viewbase.cpp
    ../cm7/touchgfx/generated/gui_generated/src/screen6_screen/: screen6viewbase.cpp
    ../cm7/touchgfx/generated/gui_generated/src/screen7_screen/: screen7viewbase.cpp
target STM32H745I_DISCO_CM7 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H745XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x00000000-0xFFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: stm32h745i_disco_CM7
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_CM7,USE_HAL_DRIVER,STM32H745xx
  c include: ../CM7/Core/Inc;../CM7/TouchGFX/App;../CM7/TouchGFX/target/generated;../CM7/TouchGFX/target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP/STM32H745I-DISCO;../Drivers/BSP/Components/Common;../Drivers/BSP/Components/mt25tl01g;../Drivers/BSP/Components/mt48lc4m32b2;../Drivers/BSP/Components/ft5336;../CM7/Core/Inc;../cm7/middlewares/st/touchgfx/framework/include;../cm7/touchgfx/generated/fonts/include;../cm7/touchgfx/generated/gui_generated/include;../cm7/touchgfx/generated/images/include;../cm7/touchgfx/generated/texts/include;../cm7/touchgfx/generated/videos/include;../cm7/touchgfx/gui/include
  asm include: ..\CM7\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: stm32h745xx_flash_CM7.sct
software components: CMSIS:CORE 4.3.0
