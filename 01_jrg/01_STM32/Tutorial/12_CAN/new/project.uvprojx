# Keil uVision project project.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F407VGTx/STCubeGenerated/Src/: main.c stm32f4xx_it.c
    ./RTE/Device/STM32F407VGTx/STCubeGenerated/Inc/: stm32f4xx_it.h
  group Includes
    ./: CAN_Conf.h CAN_LL_Management.c CAN_LL_Management.h
  group Targets
    ./: HWDef.h
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0, CMSIS:RTOS:Keil RTX5 5.5.2, CMSIS:RTOS2:Keil RTX5 5.5.2, Device:STM32Cube HAL:ADC 1.7.9, Device:STM32Cube HAL:CAN 1.7.9, Device:STM32Cube HAL:Common 1.7.9, Device:STM32Cube HAL:Cortex 1.7.9, Device:STM32Cube HAL:DMA 1.7.9, Device:STM32Cube HAL:EXTI 1.7.9, Device:STM32Cube HAL:GPIO 1.7.9, Device:STM32Cube HAL:I2C 1.7.9, Device:STM32Cube HAL:IWDG 1.7.9, Device:STM32Cube HAL:PWR 1.7.9, Device:STM32Cube HAL:RCC 1.7.9, Device:STM32Cube HAL:SPI 1.7.9, Device:STM32Cube HAL:TIM 1.7.9, Device:STM32Cube HAL:WWDG 1.7.9, Device:Startup 2.6.3
