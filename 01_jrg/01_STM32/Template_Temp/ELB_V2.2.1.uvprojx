# Keil uVision project ELB_V2.2.1.uvprojx, settings and files
target Engine_Lower_Box (6160000::V6.16::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ELB_V2.2.1 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HW_ELB
  c include: .\User;.\Target
  asm include: ..\ELB_V2.2.1;.\User
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: Analog_management.c Analog_management.h Timers_management.c Timers_management.h CAN_LL_management.c CAN_LL_management.h CAN_TX.c CAN_RX.c CAN_Conf.h TR_management.c TR_management.h GPIO_management.c GPIO_management.h IWDG.c IWDG.h main.c Switch_management.c Switch_management.h Incremental_management.c Incremental_management.h Serial_Number.c Serial_Number.h
  group Target
    ./Target/: Hardware_Def.h
target R5_Lower_Box (6140000::V6.14::ARMCLANG)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: as above
  output: ELB_V2.0 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HW_R5_ELB
  c include: .\User;.\Target
  asm include: ..\ELB_V1.1;.\User
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target Central_Console (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: as above
  output: ELB_V2.0 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HW_CONSOLE
  c include: .\User;.\Target
  asm include: ..\ELB_V1.1;.\User
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target CAN_HUB (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: as above
  output: ELB_V2.1 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HW_CAN_HUB
  c include: .\User;.\Target
  asm include: ..\ELB_V2.1;.\User
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target Sensor_Interface (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: as above
  output: ELB_V2.0 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HW_SI
  c include: .\User;.\Target
  asm define: HW_SI
  asm include: .\User;.\Target
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.3.0, CMSIS:CORE 5.4.0, CMSIS:RTOS:Keil RTX5 5.5.1, CMSIS:RTOS:Keil RTX5 5.5.2, CMSIS:RTOS2:Keil RTX5 5.5.1, CMSIS:RTOS2:Keil RTX5 5.5.2, Device:STM32Cube Framework:Classic 1.7.6, Device:STM32Cube Framework:Classic 1.7.9, Device:STM32Cube HAL:ADC 1.7.6, Device:STM32Cube HAL:ADC 1.7.9, Device:STM32Cube HAL:CAN 1.7.6, Device:STM32Cube HAL:CAN 1.7.9, Device:STM32Cube HAL:Common 1.7.6, Device:STM32Cube HAL:Common 1.7.9, Device:STM32Cube HAL:Cortex 1.7.6, Device:STM32Cube HAL:Cortex 1.7.9, Device:STM32Cube HAL:DMA 1.7.6, Device:STM32Cube HAL:DMA 1.7.9, Device:STM32Cube HAL:GPIO 1.7.6, Device:STM32Cube HAL:GPIO 1.7.9, Device:STM32Cube HAL:IWDG 1.7.6, Device:STM32Cube HAL:IWDG 1.7.9, Device:STM32Cube HAL:PWR 1.7.6, Device:STM32Cube HAL:PWR 1.7.9, Device:STM32Cube HAL:RCC 1.7.6, Device:STM32Cube HAL:RCC 1.7.9, Device:STM32Cube HAL:SPI 1.7.6, Device:STM32Cube HAL:SPI 1.7.9, Device:STM32Cube HAL:TIM 1.7.6, Device:STM32Cube HAL:TIM 1.7.9, Device:Startup 2.6.3
