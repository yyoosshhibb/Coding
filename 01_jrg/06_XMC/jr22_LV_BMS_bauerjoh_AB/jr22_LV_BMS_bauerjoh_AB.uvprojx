# Keil uVision project jr22_LV_BMS_bauerjoh_AB.uvprojx, settings and files
target XMC4500-F100x1024 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: XMC4500-F100x1024 Infineon
  pack: Infineon.XMC4000_DFP.2.13.0
  cpu: IRAM(0x20000000,0xFFC0) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x0C000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: jr22_LV_BMS_bauerjoh_AB
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0xc000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0xffc0
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS:Keil RTX5 5.5.3, CMSIS:RTOS2:Keil RTX5 5.5.3, Device:Startup 2.2.4, Device:XMClib:CAN 2.1.24, Device:XMClib:CCU4 2.1.24, Device:XMClib:CCU8 2.1.24, Device:XMClib:DAC 2.1.24, Device:XMClib:DMA 2.1.24, Device:XMClib:DSD 2.1.24, Device:XMClib:EBU 2.1.24, Device:XMClib:ERU 2.1.24, Device:XMClib:ETH_MAC 2.1.24, Device:XMClib:FCE 2.1.24, Device:XMClib:FLASH 2.1.24, Device:XMClib:GPIO 2.1.24, Device:XMClib:HRPWM 2.1.24, Device:XMClib:I2C 2.1.24, Device:XMClib:I2S 2.1.24, Device:XMClib:LEDTS 2.1.24, Device:XMClib:POSIF 2.1.24, Device:XMClib:RTC 2.1.24, Device:XMClib:SCU 2.1.24, Device:XMClib:SDMMC 2.1.24, Device:XMClib:SPI 2.1.24, Device:XMClib:UART 2.1.24, Device:XMClib:USB 2.1.24, Device:XMClib:VADC 2.1.24, Device:XMClib:WDT 2.1.24
